# Repository hosh0344/CatchRobo2026_Circuits

File README.md:

# キャチロボ2026で使用した回路 <br>

## 1. DCMD2026

ブラシ付きDCモータドライバ基板

STM32G431を使用し、ハードウェアタイマーによりエンコーダーパルスを自動でカウントすることができる。CAN、リミットスイッチなどに対応しており、パターン的には20A程度流せるように設計している。

## 2. PWSP2026

従来のPWSPをマイナーチェンジした基板

AND回路による緊停を撤廃し、直接PMOSのゲートをハイインピーダンスにすることによってロジック部に依存しない方式に変更した。CANはオプションで搭載しているが、基本的には使わない方針である。

**※従来のPWSPとは緊急停止の規格が異なっているため併用は不可能**

## 3. MainController2026

STM32G474RET6を用いたコントローラ基板

各基板とCANを行うための中央制御基板として用いた。CANは2系統に対応。各タクトスイッチにはシュミットトリガICによるチャタリング防止機能がついているほか、中央のOLEDにはCANの状態監視機能を実装しているため、デバッグ等にも用いることができる。あと純粋にかっこいい。

## 4. EndEffecterBoard2026

基板データは[こちら](https://github.com/hosh0344/EndEffecterBoard2026)

3つのポンプと3つのサーボ、FEETECH社のSTS3215を制御できるほか、DCMD同様にハードウェアエンコーダカウントができる。

## KiCad design DCMD2026/DRC-DCMD2026_Ver1.0.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C15, C16, C17, C20, C21, C27, C28: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C13, C14: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C18, C19, C22: 220u; CP_Elec_6.3x9.9
C24, C25, C26, C29: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D8, D9: SS2040FL; D_SOD-123F
D3: NSSM065T; LED_RGB_PLCC-6
D4: +3V3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D10: 1N4148; D_SOD-123F; not fitted
J1: LIM; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: USB_C; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J4: SWD; IDC-Header_2x05_P2.54mm_Vertical
J5: ENC; JST_XH_S5B-XH-A_1x05_P2.50mm_Horizontal
J6, J7: CAN; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J8: +BATT; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J9: OUTPUT; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
JP1: TR; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: REG; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm_NumberLabels
Q1, Q2, Q3, Q4: NMOS; TO-252-2
R1, R2, R5, R22, R23, R24, R25: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8, R9, R10, R12, R14, R15: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R17: 1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18, R19, R20, R21: 47; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: RST; SW_SPST_PTS810
U1: STM32G431CBTx; LQFP-48_7x7mm_P0.5mm
U2: CH340E; MSOP-10_3x3mm_P0.5mm; LCSC C99652
U3: 74LVC2T45DC; VSSOP-8_2.3x2mm_P0.5mm
U4: ATA6561; SOIC-8_3.9x4.9mm_P1.27mm
U5: AZ1117CH-3.3; SOT-223-3_TabPin2
U6, U7: TLP152; SO-5-6_4.55x3.7mm_P1.27mm
U8, U9: IR2302; SO-8_3.9x4.9mm_P1.27mm
U10: NJM7812; TO-252-2
Y1: 16MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm_HandSoldering

Connections:
+3V3: C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, C14.1, C15.1, R1.1, R10.1, U1.1 (VBAT), U1.20 (VREF+), U1.21 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U2.7 (VCC), U2.10 (V3), U3.1 (VCCA), U4.5 (Vio), U5.2 (VO)
+5V: C10.1, C11.2, C12.1, C13.1, D1.1 (K), D2.1 (K), J5.4, J6.4, J7.4, U3.8 (VCCB), U4.3 (VDD), U5.3 (VI)
+12V: C16.2, C17.2, C20.2, C21.2, JP2.2 (C), R16.1, R17.1, U6.6 (VDD), U7.6 (VDD), U8.1 (VCC), U9.1 (VCC)
+BATT: C18.1, C19.1, C22.1, C26.1, C27.1, D10.1 (K), J8.2, JP2.3 (B), Q1.2 (D), Q3.2 (D), U10.1 (IN)
/A: J5.3, U3.6 (2B)
/B: J5.5, U3.7 (1B)
/BOOT0: R2.2, U1.45 (PB8)
/NRST: C1.2, J4.1, R1.2, SW1.2, U1.7 (PG10)
/OUTA: C24.2, J9.2, Q1.3 (S), Q2.2 (D), R22.2, U8.6 (VS)
/OUTB: C25.2, J9.1, Q3.3 (S), Q4.2 (D), R24.1, U9.6 (VS)
/SWCLK: J4.2, U1.38 (PA14)
/SWDIO: J4.4, U1.37 (PA13)
/X: J5.2, R5.1
CAN_H: J6.3, J7.3, JP1.2 (B), U4.7 (CANH)
CAN_L: J6.2, J7.2, R11.2, U4.6 (CANL)
CAN_RX: U1.33 (PA11), U4.4 (RXD)
CAN_TX: U1.34 (PA12), U4.1 (TXD)
ENC_A: U1.14 (PA6), U3.3 (2A)
ENC_B: U1.15 (PA7), U3.2 (1A)
ENC_X: R5.2, R6.1, U1.13 (PA5)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C8.1, C9.1, C10.2, C11.1, C12.2, C13.2, C14.2, C15.2, D3.1 (BK), D3.2 (RK), D3.3 (GK), D4.1 (K), D5.1 (K), J1.1, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J4.5, J4.6, J5.1, J6.1, J7.1, R2.1, R3.2, R4.2, R6.2, SW1.1, U1.19 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.3 (GND), U3.4 (GND), U3.5 (DIR), U4.2 (VSS), U4.8 (STBY), U5.1 (GND), U6.3 (K), U7.3 (K), Y1.2
GNDPWR: C16.1, C17.1, C18.2, C19.2, C20.1, C21.1, C22.2, C26.2, C27.2, C28.1, C29.1, J8.1, Q2.3 (S), Q4.3 (S), R23.1, R25.2, U6.4 (GND), U7.4 (GND), U8.4 (COM), U9.4 (COM), U10.2 (GND)
LED: R12.1, U1.41 (PB4)
LIM: J1.2, U1.16 (PB0)
unnamed: D2.2 (A), J4.9, J4.10
unnamed: D3.6 (BA), R7.2
unnamed: D3.4 (GA), R9.2
unnamed: D3.5 (RA), R8.2
unnamed: D4.2 (A), R10.2
unnamed: D5.2 (A), R12.2
unnamed: D8.2 (A), R16.2
unnamed: C24.1, D8.1 (K), U8.8 (VB)
unnamed: D9.2 (A), R17.2
unnamed: C25.1, D9.1 (K), U9.8 (VB)
unnamed: C28.2, C29.2, D10.2 (A), JP2.1 (A), U10.3 (OUT)
unnamed: J2.A5 (CC1), R3.1
unnamed: J2.B5 (CC2), R4.1
unnamed: JP1.1 (A), R11.1
unnamed: Q1.1 (G), R18.2, R22.1
unnamed: Q2.1 (G), R19.1, R23.2
unnamed: Q3.1 (G), R20.2, R24.2
unnamed: Q4.1 (G), R21.1, R25.1
unnamed: U1.5 (PF0), Y1.1
unnamed: U1.6 (PF1), Y1.3
unnamed: J2.A6 (D+), J2.B6 (D+), U2.1 (UD+)
unnamed: J2.A7 (D-), J2.B7 (D-), U2.2 (UD-)
unnamed: R14.2, U6.1 (A)
unnamed: U6.5 (VO), U8.2 (IN)
unnamed: R15.2, U7.1 (A)
unnamed: U7.5 (VO), U9.2 (IN)
unnamed: R18.1, U8.7 (HO)
unnamed: R19.2, U8.5 (LO)
unnamed: R20.1, U9.7 (HO)
unnamed: R21.2, U9.5 (LO)
RGB_B: R7.1, U1.9 (PA1)
RGB_G: R8.1, U1.10 (PA2)
RGB_R: R9.1, U1.11 (PA3)
TIM1_CH1: R14.1, U1.30 (PA8)
TIM1_CH2: R15.1, U1.31 (PA9)
UART2_RX: U1.39 (PA15), U2.8 (TXD)
UART2_TX: U1.40 (PB3), U2.9 (RXD)
VBUS: D1.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)

Board: 2 copper layers, 80.0 x 60.0 mm, 86 parts (17 on the bottom side), 62 nets.

## KiCad design MainController2026/MainController_ver2.0.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C7, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C33: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C10: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9: 0.01u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C31, C32: 12p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: SS2040FL; D_SOD-123F
D2: NSSM065T; LED_RGB_PLCC-6
D3: 1N4148; D_SOD-123
D4: 3V3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: 5V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1: FerriteBead_Small; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: USB-UART; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: ST-LINK; PinHeader_1x04_P2.54mm_Horizontal
J3: SW_R; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J4: SW_L; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J5: ST7789; PinSocket_1x08_P2.54mm_Vertical
J6: CAN2; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J7: CAN3; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
JP1, JP2: TR; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R4, R5, R9, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R7, R8, R10, R11: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R13: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: MCU; SW_SPST_PTS810
SW5: Up; SW_PUSH-12mm
SW6: Right; SW_PUSH-12mm
SW7: Left; SW_PUSH-12mm
SW8: Down; SW_PUSH-12mm
SW9: Circle; SW_PUSH-12mm
SW10: Cross; SW_PUSH-12mm
SW11: Square; SW_PUSH-12mm
SW12: Triangle; SW_PUSH-12mm
U1: STM32G474RETx; LQFP-64_10x10mm_P0.5mm
U2: TLV1117; SOT-223-3_TabPin2
U3, U4: JOYSTICK; joystick; PARTREV N/A
U5, U6: ATA6561; SOIC-8_3.9x4.9mm_P1.27mm
U7, U8: 74LCX14FT; TSSOP-14_4.4x5mm_P0.65mm
U9: CH340E; MSOP-10_3x3mm_P0.5mm; LCSC C99652
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C1.2, C2.2, C3.2, C4.2, C5.2, C10.1, C11.1, C12.2, C13.2, C20.2, C29.2, C33.2, D3.2 (A), FB1.1, J5.2, R1.2, R5.2, R9.2, R10.1, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, U1.1 (VBAT), U1.16 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U2.2 (VO), U3.H1 (H+), U3.V1 (V+), U4.H1 (H+), U4.V1 (V+), U5.5 (Vio), U6.5 (Vio), U7.14 (VCC), U8.14 (VCC), U9.7 (VCC), U9.10 (V3)
+5V: C7.1, C8.1, C14.2, C15.2, D1.1 (K), D3.1 (K), J6.4, J7.4, R11.1, U2.3 (VI), U5.3 (VDD), U6.3 (VDD)
/BOOT0: R4.2, U1.61 (PB8)
/CAN2H: J6.3, JP1.2 (B), U5.7 (CANH)
/CAN2L: J6.2, R12.2, U5.6 (CANL)
/CAN2_RX: U1.34 (PB12), U5.4 (RXD)
/CAN2_TX: U1.35 (PB13), U5.1 (TXD)
/CAN3H: J7.3, JP2.2 (B), U6.7 (CANH)
/CAN3L: J7.2, R13.2, U6.6 (CANL)
/CAN3_RX: U1.42 (PA8), U6.4 (RXD)
/CAN3_TX: U1.51 (PA15), U6.1 (TXD)
/Circle: C25.2, R17.1, SW9.1, U7.5
/Cross: C26.2, R18.1, SW10.1, U7.9
/Down: C24.2, R16.1, SW8.1, U8.13
/L: J4.3, R23.1, U7.11
/Left: C23.2, R15.1, SW7.1, U8.1
/NRST: C30.2, J2.4, R1.1, SW1.2, U1.7 (PG10)
/R: J3.3, R21.1, U8.11
/Right: C22.2, R14.1, SW6.1, U8.5
/SWCLK: J2.3, U1.50 (PA14)
/SWDIO: J2.2, U1.49 (PA13)
/Square: C27.2, R19.1, SW11.1, U7.1
/Triangle: C28.2, R20.1, SW12.1, U7.3
/USART1_RX: U1.23 (PC5), U9.8 (TXD)
/USART1_TX: U1.22 (PC4), U9.9 (RXD)
/Up: C21.2, R5.1, SW5.1, U8.3
/VDDA: C6.2, C9.2, FB1.2, U1.28 (VREF+), U1.29 (VDDA)
/ZL: J4.2, R24.1, U7.13
/ZR: J3.2, R22.1, U8.9
ADC1_IN1: C16.2, U1.12 (PA0), U3.V2 (V)
ADC1_IN2: C17.2, U1.13 (PA1), U3.H2 (H)
ADC1_IN3: C18.2, U1.14 (PA2), U4.V2 (V)
ADC1_IN4: C19.2, U1.17 (PA3), U4.H2 (H)
BLK: J5.8, U1.41 (PC9)
CS: J5.7, U1.43 (PA9)
DC: J5.6, U1.20 (PA6)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C8.2, C9.1, C10.2, C11.2, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.2, C32.2, C33.1, D2.1 (BK), D2.2 (RK), D2.3 (GK), D4.1 (K), D5.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, R2.2, R3.2, R4.1, SW1.1, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, U1.15 (VSS), U1.27 (VSSA), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.1 (GND), U3.B2A (SEL-), U3.H3 (H-), U3.S1 (SHIELD), U3.S2 (SHIELD), U3.S3 (SHIELD), U3.S4 (SHIELD), U3.V3 (V-), U4.B2A (SEL-), U4.H3 (H-), U4.S1 (SHIELD), U4.S2 (SHIELD), U4.S3 (SHIELD), U4.S4 (SHIELD), U4.V3 (V-), U5.2 (VSS), U5.8 (STBY), U6.2 (VSS), U6.8 (STBY), U7.7 (GND), U8.7 (GND), U9.3 (GND), Y1.2
LCD_RES: J5.5, R9.1, U1.44 (PA10)
unnamed: D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: D2.6 (BA), R6.2
unnamed: D2.4 (GA), R8.2
unnamed: D2.5 (RA), R7.2
unnamed: D4.2 (A), R10.2
unnamed: D5.2 (A), R11.2
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R3.1
unnamed: JP1.1 (A), R12.1
unnamed: JP2.1 (A), R13.1
unnamed: C31.1, U1.5 (PF0), Y1.1
unnamed: C32.1, U1.6 (PF1), Y1.3
unnamed: J1.A6 (D+), J1.B6 (D+), U9.1 (UD+)
unnamed: J1.A7 (D-), J1.B7 (D-), U9.2 (UD-)
OPERATION: U1.2 (PC13)
PUSH_L: R25.1, U1.3 (PC14), U3.B1A (SEL+)
PUSH_R: R26.1, U1.18 (PA4), U4.B1A (SEL+)
SIDE_L: U1.56 (PB3), U7.10
SIDE_R: U1.36 (PB14), U8.10
SIDE_ZL: U1.57 (PB4), U7.12
SIDE_ZR: U1.37 (PB15), U8.8
SPI1_MOSI: J5.4, U1.21 (PA7)
SPI1_SCK: J5.3, U1.19 (PA5)
SW_Circle: U1.9 (PC1), U7.6
SW_Cross: U1.8 (PC0), U7.8
SW_Down: U1.30 (PB10), U8.12
SW_Left: U1.26 (PB2), U8.2
SW_Right: U1.24 (PB0), U8.6
SW_Square: U1.11 (PC3), U7.2
SW_Triangle: U1.10 (PC2), U7.4
SW_Up: U1.25 (PB1), U8.4
TIM8_CH1: R6.1, U1.38 (PC6)
TIM8_CH2: R7.1, U1.39 (PC7)
TIM8_CH3: R8.1, U1.40 (PC8)

Notes on the sheet:
Tactile Switch
MCU
Analog Joystick
USB-UART
CAN通信
LCD
LED

Board: 2 copper layers, 140.0 x 65.0 mm, 93 parts (66 on the bottom side), 71 nets.

## KiCad design PWSP2026/DRC-PWSP2026.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C3, C4, C7, C9, C10, C16, C18, C19: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C11: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C8: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12, C13, C14, C15: 22u; C_Radial_D5.0mm_H11.0mm_P2.00mm
C17: 4.7u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1: +5V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3, D10, D12: SS2040FL; D_SOD-123F
D4: 5.1V; D_SOD-123
D5: STATUS; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D6: OUT1; LED_D3.0mm_Clear
D7: OUT2; LED_D3.0mm_Clear
D8: OUT3; LED_D3.0mm_Clear
D9: OUT4; LED_D3.0mm_Clear
D11: EMG; LED_D3.0mm
J1: USB; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2, J3: CAN; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J4: EMG; TerminalBlock_bornier-2_P5.08mm
J5: OUT1; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J6: OUT2; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J7: OUT3; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J8: OUT4; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J9: INPUT; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J10: 5V; PinHeader_1x02_P2.54mm_Vertical
J11: GND; PinHeader_1x02_P2.54mm_Vertical
JP1: BOOT; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: CAN_TR; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1, Q2, Q3, Q4: Q_PMOS_GDS; TO-252-2
Q5, Q6, Q7, Q8: DTC143ZU3; SOT-323_SC-70_Handsoldering
R1, R3, R37, R38, R39, R40: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4, R5, R6, R7, R10, R11: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 2.4k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R41: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R29, R30, R31, R32, R33, R34, R35, R36: R_Small; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: RESET; SW_SPST_PTS810
SW2: MODE; SW_DIP_SPSTx02_Slide_Copal_CHS-02B_W7.62mm_P1.27mm
U1: R7FA4M1AB3CFM_AA0; PARTREV 1.1
U2: MCP2562-H-SN; SOIC-8_3.9x4.9mm_P1.27mm
U3: TLP293-4; SOIC-16_4.55x10.3mm_P1.27mm
U4: 74HC595; SOIC-16W_5.3x10.2mm_P1.27mm
U5: M78AR05-0.5; Converter_DCDC_TRACO_TSR0.5-24xx_TSR0.5-24xxx_THT
U6, U7, U8: OSL10561; D1X8K

Connections:
+3.3V: C6.2, C7.1, U1.4 (VBATT), U1.20 (VCC_USB)
+5V: BZ1.1 (-), C1.1, C2.2, C3.2, C4.1, C9.2, C10.2, C16.2, C19.2, D3.1 (K), D5.1 (VDD), D12.1 (K), J10.1 (A), R1.1, R2.1, R4.1, R7.1, R10.2, R11.2, R13.1, U1.11 (VCC), U1.21 (VCC_USB_LDO), U1.39 (VCC), U1.56 (AVCC0), U2.3 (VDD), U2.5 (Vio), U4.10 (~SRCLR), U4.16 (VCC)
+BATT: C12.1, C13.1, C14.1, C15.1, C17.1, J9.2, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), R15.1, R17.1, R18.1, R23.1, R24.1, R41.1, U5.1 (Vin)
+OUT1: D6.2 (A), J5.2, Q1.2 (D)
+OUT2: D7.2 (A), J6.2, Q2.2 (D)
+OUT3: D8.2 (A), J7.2, Q3.2 (D)
+OUT4: D9.2 (A), J8.2, Q4.2 (D)
/A: R30.2, U6.7 (A), U7.7 (A), U8.7 (A)
/A0: C11.2, D4.1 (K), R15.2, R16.1, U1.53 (DA0/AN009/P014)
/A5: U1.48 (GTIOC5B/AN022/P100)
/B: R29.2, U6.6 (B), U7.6 (B), U8.6 (B)
/BOOT: JP1.2 (B), R11.1, U1.26 (MD/P201)
/C: R35.2, U6.4 (C), U7.4 (C), U8.4 (C)
/D: R34.2, U6.2 (D), U7.2 (D), U8.2 (D)
/D0/RX: SW2.1, U1.31 (GTIOC4B/P301)
/D1/TX: SW2.2, U1.30 (GTIOC4A/P302)
/D12/MISO: U1.35 (CRX0/RDI/GTIOC1B/P110)
/DP: R36.2, U6.5 (DP), U7.5 (DP), U8.5 (DP)
/E: R33.2, U6.1 (E), U7.1 (E), U8.1 (E)
/F: R31.2, U6.9 (F), U7.9 (F), U8.9 (F)
/G: R32.2, U6.10 (G), U7.10 (G), U8.10 (G)
BZ: Q8.1 (B), U1.47 (GTIOC5A/AN021/P101)
CAN_H: J2.3, J3.3, JP2.2 (B), U2.7 (CANH)
CAN_L: J2.2, J3.2, R12.2, U2.6 (CANL)
CAN_RX: U1.46 (ADTRG0/GTIOC2B/AN020/P102), U2.4 (RXD)
CAN_TX: U1.45 (GTIOC2A/AN019/P103), U2.1 (TXD)
CS: U1.37 (GTIOC3B/P112), U4.12 (RCLK)
DIGI0: Q5.1 (B), U1.62 (P002)
DIGI1: Q6.1 (B), U1.63 (P001)
DIGI2: Q7.1 (B), U1.64 (AN000/P000)
EMG: D11.1 (K), J4.2, U3.9, U3.11, U3.13, U3.15
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.1, C7.2, C8.2, C9.1, C10.1, C16.1, C19.1, D1.1 (K), D2.1 (K), D5.3 (VSS), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.1, J3.1, J11.1 (A), JP1.1 (A), Q5.2 (E), Q6.2 (E), Q7.2 (E), Q8.2 (E), R6.2, R8.2, R9.2, R14.2, SW1.1, SW2.3, SW2.4, U1.8 (VSS), U1.17 (VSS_USB), U1.40 (VSS), U1.57 (AVSS0), U2.2 (VSS), U2.8 (STBY), U3.2, U3.4, U3.6, U3.8, U4.8 (GND), U4.13 (~OE)
GNDPWR: C11.1, C17.2, C18.1, D4.2 (A), J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J11.2 (B), R16.2, R21.2, R22.2, R27.2, R28.2, U5.2 (GND)
LED: R3.1, U1.29 (GTIOC7B/P303)
unnamed: BZ1.2 (+), Q8.3 (C)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R3.2
unnamed: D3.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: D6.1 (K), R21.1
unnamed: D7.1 (K), R22.1
unnamed: D8.1 (K), R27.1
unnamed: D9.1 (K), R28.1
unnamed: C18.2, D10.2 (A), U5.3 (Vout)
unnamed: D10.1 (K), J10.2 (B)
unnamed: D11.2 (A), R41.2
unnamed: D12.2 (A), J2.4, J3.4
unnamed: J1.A5 (CC1), R8.1
unnamed: J1.B5 (CC2), R9.1
unnamed: JP2.1 (A), R12.1
unnamed: C12.2, Q1.1 (G), R17.2, R19.1
unnamed: C13.2, Q2.1 (G), R18.2, R20.1
unnamed: C14.2, Q3.1 (G), R23.2, R25.1
unnamed: C15.2, Q4.1 (G), R24.2, R26.1
unnamed: Q5.3 (C), U6.3 (CC), U6.8 (CC)
unnamed: Q6.3 (C), U7.3 (CC), U7.8 (CC)
unnamed: Q7.3 (C), U8.3 (CC), U8.8 (CC)
unnamed: R5.2, R6.1
unnamed: R19.2, U3.10
unnamed: R20.2, U3.12
unnamed: R25.2, U3.14
unnamed: R26.2, U3.16
unnamed: R37.2, U3.7
unnamed: R38.2, U3.5
unnamed: R39.2, U3.3
unnamed: R40.2, U3.1
unnamed: R13.2, R14.1, U1.49 (GTIOC2A/AN016/P500)
unnamed: R10.1, U1.27 (NMI/INPUT/GTIOC1A/P200)
unnamed: C5.1, R2.2, U1.59 (P010/AN005/VREFH0)
unnamed: R4.2, R5.1, U1.16 (P407/USB_VBUS/ADTRG0)
unnamed: C8.1, U1.5 (VCL)
unnamed: R29.1, U4.15 (QA)
unnamed: R30.1, U4.1 (QB)
unnamed: R31.1, U4.2 (QC)
unnamed: R32.1, U4.3 (QD)
unnamed: R33.1, U4.4 (QE)
unnamed: R34.1, U4.5 (QF)
unnamed: R35.1, U4.6 (QG)
unnamed: R36.1, U4.7 (QH)
RESET: R7.2, SW1.2, U1.25 (~RES)
RGB: D5.4 (DIN), U1.28 (GTIOC7A/P304)
SCLK: U1.36 (GTIOC3A/P111), U4.11 (SRCLK)
SER: U1.34 (CTX0/TDO/SWO/GTIOC1A/P109), U4.14 (SER)
SW1: R37.1, U1.44 (GTIOC1B/P104)
SW2: R38.1, U1.43 (GTIOC1A/P105)
SW3: R39.1, U1.42 (GTIOC0B/P106)
SW4: R40.1, U1.41 (GTIOC0A/P107)
USB_D_N: J1.A7 (D-), J1.B7 (D-), U1.18 (P915/USB_DM)
USB_D_P: J1.A6 (D+), J1.B6 (D+), U1.19 (P914/USB_DP)

Notes on the sheet:
CR時定数: τ=0.22[s]
Pch MOSFET: TJ60S04M3L(TOSHIBA)
